VERSION 5.8 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;
UNITS
   DATABASE MICRONS 1000 ;
END UNITS

MACRO my_logo
   CLASS BLOCK ;
   FOREIGN my_logo 0 0 ;
   SIZE 37.800 BY 27.600 ;
   SYMMETRY X Y ;
   OBS
      LAYER met4 ;
         RECT 0 0 37.800 27.600 ;
   END
END my_logo
